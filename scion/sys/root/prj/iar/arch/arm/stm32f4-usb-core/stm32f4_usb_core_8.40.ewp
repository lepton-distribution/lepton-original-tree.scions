# IAR project stm32f4_usb_core_8.40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc/legacy; c:/tauon/sys/root/src/kernel/usb\stm32f4-usb-core/core; c:/tauon/sys/root/src/kernel/usb\stm32f4-usb-core/stm32_usb_device_library/Core/Inc; c:/tauon/sys/root/src/kernel/usb\stm32f4-usb-core/stm32_usb_device_library/Class/AUDIO/Inc; c:/tauon/sys/root/src/kernel/usb\stm32f4-usb-core/stm32_usb_device_library/Class/MSC/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32f4_usb_core.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group kernel/core/usb/stm32_usb_core
    ../../../../../src/kernel/core/usb/stm32_usb_core/: usb_core.c usb_core.h usb_core_audio.c usb_core_audio.h usb_core_storage.c usb_core_storage.h
  group kernel/usb/stm32f4-usb-core/core
    ../../../../../src/kernel/usb/stm32f4-usb-core/core/: usb_device.c usb_device.h usbd_audio_if.c usbd_audio_if.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h usbd_storage_if.c usbd_storage_if.h
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/class/audio/inc
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Class/AUDIO/Inc/: usbd_audio.h usbd_audio_core.h usbd_audio_if_template.h
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/class/audio/src
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Class/AUDIO/Src/: usbd_audio-donotdiffused.c usbd_audio.c usbd_audio_core.c usbd_audio_if_template.c
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/class/msc/inc
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Class/MSC/Inc/: usbd_msc.h usbd_msc_bot.h usbd_msc_data.h usbd_msc_scsi.h
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/class/msc/src
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/core/inc
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group kernel/usb/stm32f4-usb-core/stm32_usb_device_library/core/src
    ../../../../../src/kernel/usb/stm32f4-usb-core/stm32_usb_device_library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
