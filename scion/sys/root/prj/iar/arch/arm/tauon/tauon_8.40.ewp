# IAR project tauon_8.40.ewp, settings and files
configuration lib-debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9D96 TexasInstruments LM3S9D96
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCDiagSuppress: pe001,pa050,pe375,pe231,pe177,pe550,pe167
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tauon.out
configuration tauon-kernel-cortex-m4-debug (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_440/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip/core
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:\tauon\sys\root\src\kernel\core\ucore\freeRTOS_8-0-0\source\portable\IAR\ARM_CM4F
configuration tauon-kernel-arm926ejs-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG; SDRAM_TARGET=1
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/AtmelSAM9XE; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7-9_388/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\boards\at91sam9261-ek; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\peripherals; C:\tauon\sys\root\src\kernel\dev\arch\at91\at91lib\utility
configuration tauon-kernel-cortex-m3-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/cpu; c:/tauon/sys/root/src/kernel/core/ucore/embOSARM7_360/src/generic; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  AARM.AUserIncludes: as above
configuration tauon-kernel-cortex-m4f-freertos-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; C:\tauon\sys\root\src\kernel\core\ucore\freeRTOS_8-0-0\source\portable\IAR\ARM_CM4F; c:/tauon/sys/root/src
configuration tauon-kernel-arm926ejs-freertos-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/AtmelSAM9XE; c:/tauon/sys/root/src
configuration tauon-kernel-cortex-m0+-freertos-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  ICCARM.CCDefines: ARM_MATH_CM0=true; NDEBUG
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  AARM.ADefines: ARM_MATH_CM0=true
  AARM.AUserIncludes: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core\ucore\freeRTOS_8-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src
configuration tauon-kernel-cortex-m4m7-freertosv9-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __SAMV71Q21__; sram; TRACE_LEVEL=4; NDEBUG
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  AARM.AUserIncludes: C:\tauon\sys\root\src\kernel\core\ucore\freeRTOS_9-0-0\source\arch\cortex-m7\at91samv71; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src
configuration tauon-kernel-cortex-m7-debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip/core
  AARM.AUserIncludes: as above
  group bin
    ../../../../../src/bin/: test2.c
  group bin/net
    ../../../../../src/bin/net/httpc/: httpc.c
    ../../../../../src/bin/net/: telnetd.c
  group kernel/core
    ../../../../../src/kernel/core/: bin.c bin.h board.h core_rttimer.h cpu.c cpu.h devconf.h dirent.c dirent.h env.c env.h errno.h etypes.h fcntl.c fcntl.h flock.c flock.h fork.h interrupt.h ioctl.h ioctl_board.h ioctl_cpu.h ioctl_encoder.h ioctl_eth.h ioctl_fb.h ioctl_hd.h ioctl_i2c.h ioctl_if.h ioctl_keyb.h ioctl_modem.h ioctl_proc.h ioctl_pwr.h ioctl_spi.h ioctl_usb.h kal.h kernel.h kernel_compiler.h kernel_io.c kernel_io.h kernel_mqueue.c kernel_mqueue.h kernel_object.h kernel_printk.c kernel_printk.h kernel_pthread.h kernel_pthread_mutex.h kernel_pthread_tsd.h kernel_ring_buffer.c kernel_ring_buffer.h kernel_sem.h kernelconf.h lib.c libstd.h limits.h malloc.c malloc.h net.h pipe.c pipe.h posix_mqueue.c posix_mqueue.h process.h rttimer.h select.c select.h signal.h stat.c stat.h statvfs.c statvfs.h syscall.h sysctl.c system.c system.h systime.c systime.h time.c time.h timer.c timer.h truncate.c types.h ver.h wait.c wait.h windef.h windows.h winnt.h
  group kernel/core/arch/arm
    ../../../../../src/kernel/core/arch/arm/: dev_dskimg.h kernel_mkconf.h
  group kernel/core/arch/cortexm
    ../../../../../src/kernel/core/arch/cortexm/: dev_dskimg.h kernel_mkconf.h
  group kernel/core/core-freertos
    ../../../../../src/kernel/core/core-freertos/: core_rttimer.c fork.c kernel.c kernel_clock.c kernel_elfloader.c kernel_object.c kernel_pthread.c kernel_pthread_mutex.c kernel_sem.c kernel_sigqueue.c kernel_timer.c process.c signal.c syscall.c
  group kernel/core/core-generic
    ../../../../../src/kernel/core/core-generic/: kernel_pthread_tsd.c
  group kernel/core/core-segger
    ../../../../../src/kernel/core/core-segger/: core_rttimer.c fork.c heap.c kernel.c kernel_clock.c kernel_elfloader.c kernel_object.c kernel_pthread.c kernel_pthread_mutex.c kernel_sem.c kernel_sigqueue.c kernel_timer.c process.c signal.c syscall.c
  group kernel/core/net
    ../../../../../src/kernel/core/net/: kernel_net_core_socket.c kernel_net_core_socket.h socket.h socks.h
  group kernel/core/net/bsd
    ../../../../../src/kernel/core/net/bsd/: netdb.h
  group kernel/core/net/bsd/inet
    ../../../../../src/kernel/core/net/bsd/inet/: in.h
  group kernel/core/net/bsd/sys
    ../../../../../src/kernel/core/net/bsd/sys/: socket.h
  group kernel/core/net/lwip_core
    ../../../../../src/kernel/core/net/lwip_core/: ethif_core.c lwip_core.c lwip_core.h lwip_core_socket.c lwip_core_socket.h
  group kernel/core/net/modem_core
    ../../../../../src/kernel/core/net/modem_core/: modem_core.c modem_core.h modem_core_api.h modem_core_socket.c modem_core_socket.h modem_socket.h
  group kernel/core/net/uip_core
    ../../../../../src/kernel/core/net/uip_core/: uip_core.c uip_core.h uip_core_socket.c uip_core_socket.h uip_slip.c uip_slip.h uip_sock.c uip_sock.h
  group kernel/core/sys
    ../../../../../src/kernel/core/sys/: mqueue.h sysctl.h utsname.h
  group kernel/core/ucore/embOSARM7_332
    ../../../../../src/kernel/core/ucore/embOSARM7_332/: OS_Error.c RTOS.h RTOSVECT.asm
  group kernel/core/ucore/embOSARM7_332/src/cpu
    ../../../../../src/kernel/core/ucore/embOSARM7_332/src/cpu/: OS_Priv.h OSCHIP.h RTOS.asm
  group kernel/core/ucore/embOSARM7_332/src/generic
    ../../../../../src/kernel/core/ucore/embOSARM7_332/src/generic/: OS_Alloc.c OS_CreateTask.c OS_CreateTaskEx.c OS_CSEMA_SignalMax.c OS_DeactivateP.c OS_DeactivateTP.c OS_DeactivateTV.c OS_DeactivateV.c OS_EvaPacketEx.c OS_EVENT_Create.c OS_EVENT_Delete.c OS_EVENT_Get.c OS_EVENT_Pulse.c OS_EVENT_Reset.c OS_EVENT_Set.c OS_EVENT_Wait.c OS_EVENT_WaitTimed.c OS_GetNumTasks.c OS_GetPrio.c OS_GetSuspendCnt.c OS_HandleTick.c OS_MEMF_Alloc.c OS_MEMF_AllocTimed.c OS_MEMF_Create.c OS_MEMF_Delete.c OS_MEMF_Free.c OS_MEMF_Info.c OS_MEMF_Internal.c OS_MEMF_Release.c OS_MEMF_Request.c OS_RAW.h OS_SetCSemaValue.c OS_SetRxCallback.c OS_Suspend.c OS_TaskIndex2Ptr.c OS_Wait.c OSBuffer.c OSCHECK.c OSCMB.c OSCom.c OSCom1.c OSCom2.c OSComRxTx1.c OSCPU.c OSCPU1.c OSCSEM.c OSCSEMGV.c OSCSEMT.c OSDELCS.c OSDELM.c OSDelRS.c OSDummy.c OSEVENCL.c OSEVENGE.c OSEVENS.c OSEvenT.c OSEVENW.c OSEVENWS.c OSEvenWST.c OSGLOBAL.c OSGM.c OSGM1.c OSGMC.c OSGMC1.c OSGMT.c OSINFO.c OSInt.h OSIsTask.c OSKern.c OSMAIL.c OSMX.c OSPM.c OSPM1.c OSPMC.c OSPMC1.c OSPMF.c OSPMF1.c OSPMFC.c OSPMFC1.c OSQ.c OSQCL.c OSQGMC.c OSQGPC.c OSQGPT.c OSRR.c OSRSEM.c OSRSEMGO.c OSRSEMGV.c OSRSEMRQ.c OSSend.c OSSETP.c osstat.c OSStatGL.c OSTERM.c OSTermE.c OSTick.c OSTickDI.c OSTIME.c OSTIMED.c OSTIMEGP.c OSTIMEGS.c OSTIMEGV.c OSTIMERX.c OSTIMES.c OSTiming.c OSTrace.c OSTrace1.c OSWAKE.c OSWM.c
  group kernel/core/ucore/embOSARM7_360/src
    ../../../../../src/kernel/core/ucore/embOSARM7_360/: OS_Error.c RTOS.h
  group kernel/core/ucore/embOSARM7_360/src/cpu
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/cpu/: OS_Priv.h OSCHIP.h RTOS.asm
  group kernel/core/ucore/embOSARM7_360/src/cpu/ext
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/cpu/ext/: OS_ARM720_MMU.c OS_ARM_MMU.c OS_VFP.c
  group kernel/core/ucore/embOSARM7_360/src/generic
    ../../../../../src/kernel/core/ucore/embOSARM7_360/src/generic/: OS_Alloc.c OS_CreateTask.c OS_CreateTaskEx.c OS_CSEMA_SignalMax.c OS_DeactivateP.c OS_DeactivateTP.c OS_DeactivateTV.c OS_EvaPacketEx.c OS_EVENT_Create.c OS_EVENT_Delete.c OS_EVENT_Get.c OS_EVENT_Pulse.c OS_EVENT_Reset.c OS_EVENT_Set.c OS_EVENT_Wait.c OS_EVENT_WaitTimed.c OS_GetNumTasks.c OS_GetPrio.c OS_GetSize.c OS_GetSuspendCnt.c OS_HandleTick.c OS_HandleTick_Ex.c OS_MEMF_Alloc.c OS_MEMF_AllocTimed.c OS_MEMF_Create.c OS_MEMF_Delete.c OS_MEMF_Free.c OS_MEMF_Info.c OS_MEMF_Internal.c OS_MEMF_Release.c OS_MEMF_Request.c OS_Power.c OS_RAW.h OS_SetCSemaValue.c OS_SetRxCallback.c OS_SetTaskName.c OS_Suspend.c OS_TaskIndex2Ptr.c OS_TickHook.c OS_Wait.c OS_Yield.c OSBuffer.c OSCHECK.c OSCMB.c OSCom.c OSCom1.c OSCom2.c OSComRxTx1.c OSCPU.c OSCPU1.c OSCSEM.c OSCSEMGV.c OSCSEMRQ.c OSCSEMT.c OSDELCS.c OSDELM.c OSDelRS.c OSDummy.c OSEVENCL.c OSEVENGE.c OSEVENS.c OSEvenT.c OSEVENW.c OSEVENWS.c OSEvenWST.c OSGLOBAL.c OSGM.c OSGM1.c OSGMC.c OSGMC1.c OSGMT.c OSINFO.c OSInt.h OSIsTask.c OSKern.c OSMAIL.c OSMX.c OSPM.c OSPM1.c OSPMC.c OSPMC1.c OSPMF.c OSPMF1.c OSPMFC.c OSPMFC1.c OSQ.c OSQCL.c OSQGMC.c OSQGPC.c OSQGPT.c OSRR.c OSRSEM.c OSRSEMGO.c OSRSEMGV.c OSRSEMRQ.c OSSend.c OSSETP.c osstat.c OSStatGL.c OSTERM.c OSTermE.c OSTickDI.c OSTickDI_Ex.c OSTIME.c OSTIMED.c OSTIMEGP.c OSTIMEGS.c OSTIMEGV.c OSTIMERX.c OSTIMES.c OSTiming.c OSTrace.c OSTrace1.c OSWAKE.c OSWM.c
  group kernel/core/ucore/embOSCXM3_380/lib
    ../../../../../src/kernel/core/ucore/embOSCXM3_380/lib/: os7m_tl__dp.a
  group kernel/core/ucore/freeRTOS_8-0-0/source
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/MemMang/: heap_2.c heap_3.c
  group kernel/core/ucore/freeRTOS_8-0-0/source/include
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/include/: croutine.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group kernel/core/ucore/freeRTOS_8-0-0/source/portable/iar/arm_926ejs
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/AtmelSAM9XE/: ISR_Support.h port.c portasm.s79 portmacro.h
  group kernel/core/ucore/freeRTOS_8-0-0/source/portable/iar/arm_cm0
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group kernel/core/ucore/freeRTOS_8-0-0/source/portable/iar/arm_cm4f
    ../../../../../src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group kernel/dev/arch/all/debug
    ../../../../../src/kernel/dev/arch/all/debug/: dev_os_debug.c dev_os_debug.h
  group kernel/dev/arch/all/eth/dev_eth_dm9000a
    ../../../../../src/kernel/dev/arch/all/eth/dev_eth_dm9000a/: dev_eth_dm9000a.c
  group kernel/dev/arch/all/flash
    ../../../../../src/kernel/dev/arch/all/flash/: flash.c flash.h
  group kernel/dev/arch/all/flash/amd
    ../../../../../src/kernel/dev/arch/all/flash/amd/: dev_flash_am29dlxxxx_1.c dev_flash_am29dlxxxx_2.c dev_flash_am29dlxxxx_3.c dev_flash_nor_amd.c dev_flash_nor_amd.h
  group kernel/dev/arch/all/flash/amd/lldapi
    ../../../../../src/kernel/dev/arch/all/flash/amd/lldapi/: lld.c lld.h lld_target_specific.h trace.c trace.h
  group kernel/dev/arch/all/flash/dev_ftl
    ../../../../../src/kernel/dev/arch/all/flash/dev_ftl/: dev_ftl.c
  group kernel/dev/arch/all/i2c
    ../../../../../src/kernel/dev/arch/all/i2c/: dev_eeprom_24xxx.c dev_eeprom_24xxx.h dev_eeprom_24xxx_0.c
  group kernel/dev/arch/all/i2c/bq
    ../../../../../src/kernel/dev/arch/all/i2c/bq/: dev_bq24161_x.c dev_bq24161_x.h dev_bq27510_g3_x.c dev_bq27510_g3_x.h
  group kernel/dev/arch/all/i2c/fram
    ../../../../../src/kernel/dev/arch/all/i2c/fram/: dev_fram_24clxx.c
  group kernel/dev/arch/all/i2c/rtc
    ../../../../../src/kernel/dev/arch/all/i2c/rtc/: dev_rtc_nxp_pca8565.c dev_rtc_nxp_pca8565.h
  group kernel/dev/arch/all/lcd
    ../../../../../src/kernel/dev/arch/all/lcd/: dev_oled_ssd1305.c dev_oled_ssd1305.h dev_oled_ssd1322.c dev_oled_ssd1322.h
  group kernel/dev/arch/all/modem/simcom
    ../../../../../src/kernel/dev/arch/all/modem/simcom/: dev_modem_simcom.c
  group kernel/dev/arch/all/modem/ublox
    ../../../../../src/kernel/dev/arch/all/modem/ublox/: dev_modem_ublox_sarag3.c dev_modem_ublox_sarag3.h
  group kernel/dev/arch/all/ppp/dev_ppp_uip
    ../../../../../src/kernel/dev/arch/all/ppp/dev_ppp_uip/: ahdlc.c ahdlc.h dev_ppp_uip.c dev_ppp_uip.h ipcp.c ipcp.h ipv6cp.c ipv6cp.h lcp.c lcp.h pap.c pap.h ppp.c ppp.h
  group kernel/dev/arch/all/sdcard
    ../../../../../src/kernel/dev/arch/all/sdcard/: dev_sdcard.c dev_sdcard.h drv_sdcard.c drv_sdcard.h drv_sdcard_arch.h
  group kernel/dev/arch/all/slip
    ../../../../../src/kernel/dev/arch/all/slip/: dev_slip.c
  group kernel/dev/arch/arm7/dev_at91
    ../../../../../src/kernel/dev/arch/arm7/dev_at91/: dev_at91.c dev_at91.h
  group kernel/dev/arch/arm7/dev_at91/dev_at91_rtt
    ../../../../../src/kernel/dev/arch/at91/dev_at91_rtt/: dev_at91_rtt.c dev_at91_rtt.h
  group kernel/dev/arch/cmsis/dev_cmsis_cpu
    ../../../../../src/kernel/dev/arch/cmsis/dev_cmsis_cpu/: dev_cmsis_cpu.c dev_cmsis_cpu.h
  group kernel/dev/arch/cmsis/dev_cmsis_itm
    ../../../../../src/kernel/dev/arch/cmsis/dev_cmsis_itm/: dev_cmsis_itm.c dev_cmsis_itm.h dev_cmsis_itm_0.c
  group kernel/dev/arch/cortexm/lm3s
    ../../../../../src/kernel/dev/arch/cortexm/stellaris/drivers/dev_lm3s_cpu/: dev_lm3s_cpu.c dev_lm3s_cpu.h
  group kernel/dev/dev_cpufs
    ../../../../../src/kernel/dev/dev_cpufs/: dev_cpufs.c dev_cpufs.h
  group kernel/dev/dev_fb
    ../../../../../src/kernel/dev/dev_fb/: dev_fb.c dev_fb.h
  group kernel/dev/dev_head
    ../../../../../src/kernel/dev/dev_head/: dev_head.c
  group kernel/dev/dev_mem
    ../../../../../src/kernel/dev/dev_mem/: dev_mem.c dev_mem.h
  group kernel/dev/dev_null
    ../../../../../src/kernel/dev/dev_null/: dev_null.c dev_null.h
  group kernel/dev/dev_proc
    ../../../../../src/kernel/dev/dev_proc/: dev_proc.c dev_proc.h
  group kernel/dev/dev_tty
    ../../../../../src/kernel/dev/dev_tty/: dev_tty.c tty_font-8x16.c tty_font-8x8.c tty_font.h
  group kernel/fs/fat/inc
    ../../../../../src/kernel/fs/fat/: fat16.h fatcore.h fatcore_msdos.h fatcore_vfat.h fatinfo.h
  group kernel/fs/fat/src
    ../../../../../src/kernel/fs/fat/: fat16.c fat16_msdos.c fat16_vfat.c fatcore.c fatcore_msdos.c fatcore_vfat.c
  group kernel/fs/fatfs
    ../../../../../src/kernel/fs/fatfs/: fatfs.c fatfs.h fatfscore.c fatfscore.h
  group kernel/fs/fatfs/core
    ../../../../../src/kernel/fs/fatfs/core/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf.h ffconf_template.h integer.h
  group kernel/fs/fatfs/core/drivers
    ../../../../../src/kernel/fs/fatfs/core/drivers/: sd_diskio.c sd_diskio.h
  group kernel/fs/kofs
    ../../../../../src/kernel/fs/kofs/: kofs.c kofs.h
  group kernel/fs/rootfs/includes
    ../../../../../src/kernel/fs/rootfs/: rootfs.h rootfscore.h
  group kernel/fs/rootfs/sources
    ../../../../../src/kernel/fs/rootfs/: rootfs.c rootfscore.c
  group kernel/fs/ufs/includes
    ../../../../../src/kernel/fs/ufs/: ufs.h ufscore.h ufsdriver.h ufsdriver_1_3.h ufsdriver_1_4.h ufsdriver_1_5.h ufsinfo.h ufsx.h
  group kernel/fs/ufs/sources
    ../../../../../src/kernel/fs/ufs/: ufs.c ufscore.c ufsdriver.c ufsdriver_1_3.c ufsdriver_1_4.c ufsdriver_1_5.c ufsx.c
  group kernel/fs/vfs/includes
    ../../../../../src/kernel/fs/vfs/: vfs.h vfscore.h vfsdev.h vfskernel.h vfstypes.h
  group kernel/fs/vfs/sources
    ../../../../../src/kernel/fs/vfs/: vfs.c vfscore.c vfsdev.c vfskernel.c
  group kernel/fs/yaffs
    ../../../../../src/kernel/fs/yaffs/: yaffs.c yaffs.h yaffscore.c yaffscore.h yaffsdriver_nor_flash.c yaffsdriver_nor_flash.h yaffsinfo.h
  group kernel/fs/yaffs/core
    ../../../../../src/kernel/fs/yaffs/core/: devextras.h yaffs_checkptrw.c yaffs_checkptrw.h yaffs_ecc.c yaffs_ecc.h yaffs_getblockinfo.h yaffs_guts.c yaffs_guts.h yaffs_nand.c yaffs_nand.h yaffs_nandemul2k.h yaffs_packedtags1.c yaffs_packedtags1.h yaffs_packedtags2.c yaffs_packedtags2.h yaffs_qsort.c yaffs_qsort.h yaffs_tagscompat.c yaffs_tagscompat.h yaffs_tagsvalidity.c yaffs_tagsvalidity.h yaffs_trace.h yaffsinterface.h yportenv.h
  group kernel/fs/yaffs/core/direct
    ../../../../../src/kernel/fs/yaffs/core/direct/: yaffs_malloc.h yaffs_norif1.c yaffs_norif1.h ydirectenv.h
  group kernel/net/lwip/api
    ../../../../../src/kernel/net/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group kernel/net/lwip/core
    ../../../../../src/kernel/net/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group kernel/net/lwip/core/ipv4
    ../../../../../src/kernel/net/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group kernel/net/lwip/netif
    ../../../../../src/kernel/net/lwip/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
  group kernel/net/lwip/ports/arm
    ../../../../../src/kernel/net/lwip/ports/arm/: lwipopts.h sys_arch.c
  group kernel/net/lwip/ports/arm/include/arch
    ../../../../../src/kernel/net/lwip/ports/arm/include/arch/: bpstruct.h cc.h epstruct.h perf.h sys_arch.h
  group lib/libc
    ../../../../../src/lib/libc/: libc.c libc.h stdint.h unistd.h
  group lib/libc/ctype
    ../../../../../src/lib/libc/ctype/: ctype.c ctype.h
  group lib/libc/misc
    ../../../../../src/lib/libc/misc/: crc.c crc.h dtostr.c ftoa.c ftoa.h itoa.c ltostr.c ltostr.h prsopt.c prsopt.h strto_l.c
  group lib/libc/net
    ../../../../../src/lib/libc/net/: htonl.c netdb.h socket.c socket.h
  group lib/libc/net/inet
    ../../../../../src/lib/libc/net/inet/: inet_addr.c
  group lib/libc/stdio
    ../../../../../src/lib/libc/stdio/: printf.c scanf.c stdio.c stdio.h
  group lib/libc/string
    ../../../../../src/lib/libc/string/: string.c string.h
  group lib/libc/termios
    ../../../../../src/lib/libc/termios/: tcgetattr.c tcsetattr.c termios.c termios.h
  group lib/libc/unistd
    ../../../../../src/lib/libc/unistd/: getopt.c getopt.h io.c unistd.c
  group lib/librt
    ../../../../../src/lib/librt/: mq.c mqueue.h sem.c semaphore.h
  group lib/pthread
    ../../../../../src/lib/pthread/: pthread.c pthread.h pthread_cond.c pthread_mutex.c
  group sbin
    ../../../../../src/sbin/: btb.c cat.c compress.c cp.c date.c df.c ecat.c echo.c initd.c kill.c ls.c lsh.c mkdir.c mkfifo.c mkfs.c more.c mount.c mv.c od.c ps.c pwd.c read.c rm.c rmdir.c shutdown.c sleep.c stty.c sync.c touch.c umount.c uname.c wrapr.c xmodem.c
  group sbin/net
    ../../../../../src/sbin/net/: ifconfig.c slipd.c
