# IAR project dev_stm32wlxx_9.50.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32WL55xx; ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; CORE_CM4; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:\tauon\sys\root\src\kernel\core\ucore\cmsis\CMSIS\Include; c:\tauon\sys\root\src\kernel\core\ucore\cmsis\Device\st\stm32wlxx; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\cubemx_hal_driver\inc; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\dev_stm32wlxx; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\radio_subghz_phy; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\radio_subghz_phy\stm32_radio_driver; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\radio_subghz_phy\stm32_radio_target; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\radio_subghz_phy\stm32_radio_core_inc; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\Utilities\misc; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\Utilities\timer; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\Utilities\trace\adv_trace; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\Utilities\sequencer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_stm32wlxx_8.40.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/arch/cortexm/stm32wlxx/cubemx_hal_driver
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/cubemx_hal_driver/src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_comp.c stm32wlxx_hal_cortex.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_dac.c stm32wlxx_hal_dac_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_gtzc.c stm32wlxx_hal_hsem.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_i2s.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_irda.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_lptim.c stm32wlxx_hal_msp_template.c stm32wlxx_hal_pka.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rng_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_smartcard.c stm32wlxx_hal_smartcard_ex.c stm32wlxx_hal_smbus.c stm32wlxx_hal_smbus_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_timebase_rtc_alarm_template.c stm32wlxx_hal_timebase_rtc_wakeup_template.c stm32wlxx_hal_timebase_tim_template.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_usart_ex.c stm32wlxx_hal_wwdg.c
  group kernel/dev/arch/cortexm/stm32wlxx/dev_stm32wlxx
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/dev_stm32wlxx/: dev_stm32wlxx_bsp_radio_if.c dev_stm32wlxx_bsp_radio_if.h dev_stm32wlxx_cpu_x.c dev_stm32wlxx_definitions.h dev_stm32wlxx_uart_x.c dev_stm32wlxx_uart_x.h
  group kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy/: lr_fhss_v1_base_types.h radio.h radio_def.h radio_ex.h
  group kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy/stm32_radio_driver
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy/stm32_radio_driver/: lr_fhss_mac.c lr_fhss_mac.h radio.c radio_driver.c radio_driver.h radio_fw.c radio_fw.h subghz_phy_version.h wl_lr_fhss.c wl_lr_fhss.h
  group kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy/stm32_radio_target
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/radio_subghz_phy/stm32_radio_target/: mw_log_conf.h radio_board_if.c radio_board_if.h radio_conf.h timer.h
  group kernel/dev/arch/cortexm/stm32wlxx/utilities/misc
    ../../../../../../src/kernel/dev/arch/cortexm/stm32wlxx/Utilities/misc/: stm32_mem.c stm32_mem.h
