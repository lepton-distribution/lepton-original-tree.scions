# IAR project bsp_discovery_f4-baseboard-modem_7.40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc/legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_discovery_f4_7.30.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/discovery_f4-baseboard-modem/dev_discovery_f4_board
    ../../../../src/kernel/dev/bsp/discovery_f4-baseboard-modem/dev_discovery_f4_board/: dev_discovery_f4_board.c dev_discovery_f4_board.h
  group kernel/dev/bsp/discovery_f4-baseboard-modem/dev_discovery_f4_peripherals
    ../../../../src/kernel/dev/bsp/discovery_f4-baseboard-modem/dev_discovery_f4_peripherals/: dev_aedr8300_encoder_1.c dev_aedr8300_encoder_2.c dev_discovery_click_420r_io.c dev_discovery_click_420r_io.h dev_discovery_f4_i2c_1.c dev_discovery_f4_nfc_pn7150.c dev_discovery_f4_sdio.c dev_discovery_f4_uart_3.c dev_discovery_f4_uart_6.c dev_discovery_oled_io.c dev_discovery_spi_1.c dev_discovery_spi_2.c dev_rotary_encoder_x.c dev_rotary_encoder_x.h dev_te86bsd_sensor.c dev_te86bsd_sensor.h
