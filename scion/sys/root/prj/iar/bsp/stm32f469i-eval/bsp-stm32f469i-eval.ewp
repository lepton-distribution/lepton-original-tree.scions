# IAR project bsp-stm32f469i-eval.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_discovery_f4_7.30.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/stm32f469i_eval/dev_stm32f469i_eval_board
    ../../../../src/kernel/dev/bsp/stm32f469i-eval/dev_stm32f469i_eval_board/: dev_stm32f469i_eval_board.c dev_stm32f469i_eval_board.h
  group kernel/dev/bsp/stm32f469i_eval/dev_stm32f469i_eval_peripherals
    ../../../../src/kernel/dev/bsp/stm32f469i-eval/dev_stm32f469i_eval_peripherals/: dev_stm32f469i_eval_i2c_1.c dev_stm32f469i_eval_spi_1.c dev_stm32f469i_eval_spi_2.c dev_stm32f469i_eval_usart_1.c
