# IAR project bsp_stm32wl55jci_nucleo_8.40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32WL55xx; ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; CORE_CM4; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:\tauon\sys\root\src\kernel\core\ucore\cmsis\CMSIS\Include; c:\tauon\sys\root\src\kernel\core\ucore\cmsis\Device\st\stm32wlxx; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\cubemx_hal_driver\inc; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\dev_stm32wlxx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_stm32wl55jci_nucleo.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_board
    ../../../../src/kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_board/: dev_stm32wl55jci_nucleo_board.c dev_stm32wl55jci_nucleo_board.h
  group kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_peripherals
    ../../../../src/kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_peripherals/: dev_stm32wl55jci_nucleo_usart_2.c
  group kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_radio
    ../../../../src/kernel/dev/bsp/stm32wl55jci_nucleo/dev_stm32wl55jci_nucleo_radio/: dev_stm32wl55jci_nucleo_radio.c stm32wlxx_nucleo_conf.h stm32wlxx_nucleo_errno.h stm32wlxx_nucleo_radio.c stm32wlxx_nucleo_radio.h
