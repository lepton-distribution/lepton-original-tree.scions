# IAR project tauon-basic_stm32wl55jci_nucleo_9.50.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32WL55xx; _OS_LIBMODE_DP; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG=1; ewarm; CORE_CM4; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:\tauon\sys\root\src\kernel\core\ucore\cmsis\Device\st\stm32wlxx; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\dev_stm32wlxx; c:\tauon\sys\root\src\kernel\dev\arch\cortexm\stm32wlxx\cubemx_hal_driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tauon-firmware-stm32wl55.hex
  ILINK.IlinkOutputFile: tauon-basic_stm32wl55.out
  ILINK.IlinkIcfFile: stm32wl55xC_m4-lepton.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCIncludePath2: ..\..\..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Start_LM3S9B96.out
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.CoreVariant: 38
  ICCARM.CCDefines: OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG=1; ewarm; PART_LM3S9B96
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; C:\tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/DeviceSupport; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: tauon-basic_stm32f4.out
  ILINK.IlinkIcfFile: FLASH.icf
  group tauon/lib
    ../../../../../../../../building/output/bsp_stm32wl55jci_nucleo_9.50/Debug/Lib/: bsp_stm32wl55jci_nucleo_9.50.a
    ../../../../../../../../building/output/dev_stm32wlxx_9.50/Debug/Lib/: dev_stm32wlxx_9.50.a
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/lib/: os7m_tl__dp.a os7m_tl__sp.a
    ../../../../../../../../building/output/tauon_9.50/tauon-kernel-cortex-m4-debug/Lib/: tauon_9.50.a
  group tauon/sys/root/kernel/core/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/lm3s
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/lm3s/: lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/: stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/startup/iar/: startup_stm32f2xx.s
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/startup/iar/: startup_stm32f4xx.s
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32wlxx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32wlxx/: stm32wl55xx.h stm32wlxx.h system_stm32wlxx.c system_stm32wlxx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32wlxx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32wlxx/startup/iar/: startup_stm32wl55xx_cm4.s
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c RTOSInit_STM32F4x_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_440/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_440/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_440/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_440/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4x_CMSIS.c SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_518/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_518/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c OS_ThreadSafe.c RTOSInit_STM32WLxx.c SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: main.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0/arch/cortex-m4/stm32f4
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
