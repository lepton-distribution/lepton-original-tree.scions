<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\bsp\stm32wl55jci_nucleo\bsp_stm32wl55jci_nucleo_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\dev\stm32wlxx\dev_stm32wlxx_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tauon-basic_stm32wl55jci_nucleo_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\tauon\tauon_8.40.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all debug</name>
            <member>
                <project>dev_stm32wlxx_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bsp_stm32wl55jci_nucleo_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon_8.40</project>
                <configuration>tauon-kernel-cortex-m4-debug</configuration>
            </member>
            <member>
                <project>tauon-basic_stm32wl55jci_nucleo_8.40</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>all freertos debug</name>
            <member>
                <project>dev_stm32f4xx_7.20</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon_7.20</project>
                <configuration>tauon-kernel-cortex-m4f-freertos-debug</configuration>
            </member>
            <member>
                <project>tauon-basic_stm32f4_7.20</project>
                <configuration>freertos-debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
